# Keil uVision project HT1623.uvproj, settings and files
target HT1623 (ARM-ADS)
  device: STMicroelectronics
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --C99
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group 
    ./: 
