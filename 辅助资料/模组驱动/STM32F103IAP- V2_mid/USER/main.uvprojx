# Keil uVision project main.uvprojx, settings and files
target PT50 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: aa +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe    --bin -o  ..\OBJ\aa.bin ..\OBJ\aa.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MyCode\Buzzer;..\MyCode\KEY;..\MyCode\ADC;..\MyCode;..\MyCode\LCD;..\MyCode\BUZ;..\MyCode\TIM;..\MyCode\LED;..\MyCode\BATTERY
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c gpio_defs.h common.c
  group MyCode
    ../MyCode/ADC/: adc.c
    ../MyCode/: oled.c
    ../MyCode/LCD/: HT61666_LCD.c
    ../MyCode/led/: LED.c
    ../MyCode/BUZ/: buzzer.c
    ../MyCode/BATTERY/: battery.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
