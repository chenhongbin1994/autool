# Keil uVision project PT50_STM32F103RC.uvprojx, settings and files
target PT50_STM32F103RC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PT50APP +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe    --bin -o  ..\Project\Objects\PT50APP.bin ..\Project\Objects\PT50APP.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\libraries\CMSIS\CM3\CoreSupport;..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\libraries\STM32F10x_StdPeriph_Driver\inc;..\App;..\System\delay;..\System\sys;..\System\usart;..\MyCode\ADC;..\MyCode\BATTERY;..\MyCode\BUZ;..\MyCode\KEY;..\MyCode\LCD;..\MyCode\LED;..\MyCode\TIMER;..\MyCode;..\USB\CONFIG;..\USB\STM32_USB-FS-Device_Driver\inc;..\MyCode\Middleware;..\MyCode\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/: main.c stm32f10x_it.c includes.h
  group MyCode
    ../MyCode/ADC/: adc.c
    ../MyCode/BUZ/: buzzer.c
    ../MyCode/BATTERY/: battery.c
    ../MyCode/TIMER/: timer.c
    ../MyCode/KEY/: key.c
    ../MyCode/LCD/: LCD_HT1623.c digit.c display.c
    ../MyCode/Middleware/: key_handler.c
    ../MyCode/FLASH/: stmflash.c
  group Doc
    ../doc/: readme.txt
  group stdlib
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Systen
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
  group USB_core
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_config
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
